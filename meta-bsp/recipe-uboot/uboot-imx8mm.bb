SUMMARY = "Recipe for building U-Boot for iMX M8 mini board"
DESCRIPTion = "This recipe builds U-Boot for iMX M8 Mini board"

LICENSE = "GPL-2.0+"

SRC_URI = git@github.com:varigit/uboot-imx.git

S = "${WORKDIR}"

